# Keil uVision project main.uvprojx, settings and files
target main (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\src;..\STM32_USB-FS-Device_Driver\inc;..\STM32F10x_StdPeriph_Driver\inc;..\CMIS\Device\STM32F10x\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMIS
    ../CMIS/Device/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group STM3210x_LIB
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c
  group USB_LIB
    ../STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USER
    ../src/: main.c system_stm32f10x.c hw_config.c stm32_it.c
  group DRIVERS
    ../src/: timer_drv.c io_input.c kbd_driver.c spi_master.c string_utils.c fonts.c
  group LCD
    ../src/: nokia_lcd.c erc12864_4.c hd44780.c lcd_st7735.c
  group USB_STUFF
    ../src/: usb_pwr.c usb_istr.c usb_prop.c
